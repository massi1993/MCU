<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\binarny_cnt.ewp</path>
    </project>
    <batchBuild />
</workspace>
