<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\src\binary_counter\binarny_cnt.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\DAC_ADC\dac_adc.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\DAC_ADC_USART\dac_adc_usart.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\PA0_EXTI\exti_PA0.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\led_on_timer\led_on_timer.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\led_on_velocity_change\led_on_velocity_change.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\Measurement_time_usingPA0\measuremente_time.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\Sine_waveform_generation\sine_waveform.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\Timer3_internal_interrupt\Tim3_Internal_interrupt.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\Usart_Flashing_led\usart_Flash_led.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\Voltage_converter\voltage-converter.ewp</path>
    </project>
    <batchBuild />
</workspace>
